# Keil uVision project bradwii-H6C.uvproj, settings and files
target bradwii-X4 (ARM-ADS)
  device: Mini54ZDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: bradwii-X4 +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: H6C_BUILD
  c misc: --gnu
  c include: lib-Mini51\hal;src;lib-Mini51\CMSIS\Include;lib-Mini51\Device\Nuvoton\Mini51Series\Include;lib-Mini51\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group App
    ./src/: accelerometer.c autotune.c baro.c bradwii.c checkboxes.c compass.c eeprom.c gps.c gyro.c imu.c navigation.c output.c pilotcontrol.c serial.c vectors.c leds.c fp_imu.c rx_v202.c nrf24l01.c
  group HAL
    ./lib-Mini51/hal/: drv_gpio.c drv_hal.c drv_pwm.c drv_serial.c lib_digitalio.c lib_fp.c lib_i2c.c lib_serial.c lib_timers.c lib_spi.c lib_soft_3_wire_spi.c lib_adc.c
  group StdDriver
    ./lib-Mini51/StdDriver/src/: adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c
  group CMSIS
    ./lib-Mini51/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ./lib-Mini51/: startup_Mini51Series.s
